# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32L475xx, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: ..\..\..\components\libc\posix\io\stdio;packages\LVGL-v8.3.3\src\extra\widgets\spinbox;..\libraries\HAL_Drivers;packages\LVGL-v8.3.3\src\draw\nxp;packages\LVGL-v8.3.3\src\extra\layouts\grid;packages\LVGL-v8.3.3\src\extra\widgets\spinner;packages\LVGL-v8.3.3\src\extra\libs\rlottie;packages\LVGL-v8.3.3\src\extra\layouts;..\..\..\components\drivers\include;packages\LVGL-v8.3.3\src\extra\libs\sjpg;board;packages\LVGL-v8.3.3\src\misc;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\drivers\include;packages\LVGL-v8.3.3\src\extra\others\gridnav;packages\LVGL-v8.3.3\src;..\..\..\libcpu\arm\cortex-m4;packages\LVGL-v8.3.3\src\extra\widgets\colorwheel;..\..\..\include;packages\LVGL-v8.3.3\src\extra\libs\bmp;packages\LVGL-v8.3.3\src\extra\others\monkey;packages\LVGL-v8.3.3\src\draw;packages\LVGL-v8.3.3\src\extra\widgets\calendar;packages\LVGL-v8.3.3\src\core;packages\LVGL-v8.3.3\src\extra\widgets\keyboard;packages\LVGL-v8.3.3\src\widgets;packages\LVGL-v8.3.3\src\extra\themes\default;board\CubeMX_Config\Inc;packages\LVGL-v8.3.3\src\extra\others\imgfont;..\..\..\components\libc\compilers\common\extension;packages\LVGL-v8.3.3\src\extra\others\msg;packages\LVGL-v8.3.3\src\extra\themes\mono;packages\LVGL-v8.3.3\src\font;packages\LVGL-v8.3.3\src\extra\libs\png;packages\LVGL-v8.3.3\src\extra\widgets\chart;packages\LVGL-v8.3.3\src\extra\libs\qrcode;packages\LVGL-v8.3.3\src\extra\libs\ffmpeg;..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;packages\LVGL-v8.3.3\src\extra\others\snapshot;packages\LVGL-v8.3.3\src\extra\themes;board\ports\lcd;packages\LVGL-v8.3.3\src\draw\nxp\vglite;.;packages\LVGL-v8.3.3\env_support\rt-thread;packages\LVGL-v8.3.3\src\hal;packages\LVGL-v8.3.3\src\extra\others;packages\LVGL-v8.3.3\src\draw\arm2d;packages\LVGL-v8.3.3\src\draw\sdl;..\..\..\components\libc\posix\io\poll;packages\LVGL-v8.3.3\src\draw\stm32_dma2d;packages\LVGL-v8.3.3\src\extra\libs;..\..\..\components\drivers\include;packages\LVGL-v8.3.3\src\extra\others\ime;packages\LVGL-v8.3.3\src\extra\widgets\list;packages\LVGL-v8.3.3\src\extra\themes\basic;packages\LVGL-v8.3.3\src\extra\widgets\tileview;packages\LVGL-v8.3.3\src\extra\widgets\menu;packages\LVGL-v8.3.3\src\extra\widgets;packages\LVGL-v8.3.3\src\extra\widgets\win;packages\LVGL-v8.3.3\src\draw\nxp\pxp;packages\LVGL-v8.3.3\src\extra\libs\freetype;packages\LVGL-v8.3.3\src\extra;..\..\..\components\drivers\spi;packages\LVGL-v8.3.3\src\extra\layouts\flex;packages\LVGL-v8.3.3\src\draw\sw;applications\lvgl;packages\LVGL-v8.3.3\src\extra\widgets\led;packages\LVGL-v8.3.3\src\extra\libs\gif;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;packages\LVGL-v8.3.3\src\draw\swm341_dma2d;..\libraries\HAL_Drivers\config;..\..\..\components\libc\compilers\common\include;..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;packages\LVGL-v8.3.3\src\extra\widgets\tabview;packages\LVGL-v8.3.3\src\extra\widgets\meter;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.3\src\extra\widgets\animimg;packages\LVGL-v8.3.3\src\extra\widgets\span;..\..\..\components\libc\posix\ipc;packages\LVGL-v8.3.3\src\extra\libs\fsdrv;packages\LVGL-v8.3.3\src\extra\widgets\msgbox;..\..\..\components\finsh;applications;packages\LVGL-v8.3.3\src\extra\widgets\imgbtn;packages\LVGL-v8.3.3\src\extra\others\fragment
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_pwm.c drv_spi.c drv_tim.c drv_usart.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/: board.c
    board/ports/lcd/: drv_lcd.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_cryp.c stm32l4xx_hal_spi.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_usart.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_lptim.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_qspi.c stm32l4xx_hal_exti.c stm32l4xx_hal_rng.c stm32l4xx_hal_crc.c stm32l4xx_hal_uart_ex.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group LVGL
    packages/LVGL-v8.3.3/src/draw/sdl/: lv_draw_sdl_texture_cache.c lv_draw_sdl_polygon.c lv_draw_sdl_utils.c lv_draw_sdl.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_stack_blur.c lv_draw_sdl_layer.c lv_draw_sdl_arc.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_composite.c lv_draw_sdl_bg.c lv_draw_sdl_rect.c
    packages/LVGL-v8.3.3/src/draw/: lv_img_decoder.c lv_img_cache.c lv_draw_line.c lv_draw_mask.c lv_draw_label.c lv_draw_arc.c lv_draw.c lv_draw_img.c lv_draw_layer.c lv_draw_transform.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c
    packages/LVGL-v8.3.3/src/font/: lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_22.c lv_font_montserrat_32.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_34.c lv_font.c lv_font_montserrat_8.c lv_font_montserrat_36.c lv_font_fmt_txt.c lv_font_simsun_16_cjk.c lv_font_montserrat_38.c lv_font_montserrat_28_compressed.c lv_font_montserrat_10.c lv_font_unscii_16.c lv_font_montserrat_42.c lv_font_montserrat_12_subpx.c lv_font_montserrat_26.c lv_font_montserrat_14.c lv_font_montserrat_44.c lv_font_montserrat_20.c lv_font_montserrat_46.c lv_font_montserrat_24.c lv_font_montserrat_12.c lv_font_montserrat_28.c lv_font_montserrat_40.c lv_font_montserrat_30.c lv_font_unscii_8.c lv_font_montserrat_48.c lv_font_loader.c
    packages/LVGL-v8.3.3/src/misc/: lv_math.c lv_utils.c lv_ll.c lv_mem.c lv_anim_timeline.c lv_style_gen.c lv_log.c lv_tlsf.c lv_lru.c lv_txt.c lv_txt_ap.c lv_printf.c lv_anim.c lv_area.c lv_fs.c lv_templ.c lv_style.c lv_timer.c lv_color.c lv_gc.c lv_bidi.c lv_async.c
    packages/LVGL-v8.3.3/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.3/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_gradient.c lv_draw_sw_rect.c lv_draw_sw_img.c lv_draw_sw_dither.c lv_draw_sw_line.c lv_draw_sw_transform.c lv_draw_sw_layer.c lv_draw_sw_polygon.c lv_draw_sw_letter.c
    packages/LVGL-v8.3.3/src/extra/: lv_extra.c
    packages/LVGL-v8.3.3/src/widgets/: lv_textarea.c lv_table.c lv_canvas.c lv_btnmatrix.c lv_checkbox.c lv_label.c lv_bar.c lv_slider.c lv_line.c lv_img.c lv_btn.c lv_dropdown.c lv_objx_templ.c lv_roller.c lv_arc.c lv_switch.c
    packages/LVGL-v8.3.3/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.3/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.3/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.3/src/core/: lv_obj_draw.c lv_theme.c lv_disp.c lv_event.c lv_obj_style_gen.c lv_group.c lv_obj_tree.c lv_indev_scroll.c lv_obj_class.c lv_refr.c lv_obj.c lv_obj_pos.c lv_indev.c lv_obj_scroll.c lv_obj_style.c
    packages/LVGL-v8.3.3/src/draw/nxp/: lv_gpu_nxp.c
    packages/LVGL-v8.3.3/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.3/src/draw/nxp/vglite/: lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c lv_draw_vglite_arc.c
    packages/LVGL-v8.3.3/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.3/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.3/src/extra/libs/fsdrv/: lv_fs_win32.c lv_fs_posix.c lv_fs_fatfs.c lv_fs_stdio.c
    packages/LVGL-v8.3.3/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.3/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.3/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.3/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_dropdown.c lv_calendar_header_arrow.c
    packages/LVGL-v8.3.3/src/draw/nxp/pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_draw_pxp_blend.c
    packages/LVGL-v8.3.3/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.3/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.3/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.3/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.3/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.3/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.3/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.3/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.3/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.3/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.3/src/hal/: lv_hal_indev.c lv_hal_tick.c lv_hal_disp.c
    packages/LVGL-v8.3.3/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.3/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.3/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.3/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.3/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.3/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.3/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.3.3/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.3/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.3/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.3/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.3/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.3/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.3/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.3/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.3/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.3/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.3/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.3/src/extra/others/snapshot/: lv_snapshot.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c lv_rt_thread_port.c
