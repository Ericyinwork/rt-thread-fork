# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32H750xx, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_HAL_DRIVER
  c include: packages\LVGL-v8.3.4\src\extra\layouts\flex;packages\LVGL-v8.3.4\src\extra\libs\rlottie;..\..\..\components\libc\posix\io\stdio;packages\LVGL-v8.3.4\src\extra\widgets\span;packages\LVGL-v8.3.4\src\font;packages\LVGL-v8.3.4\src\draw\nxp;packages\LVGL-v8.3.4\src\draw;packages\LVGL-v8.3.4\src\extra\others\snapshot;..\libraries\HAL_Drivers;packages\CmBacktrace-v1.4.1;packages\LVGL-v8.3.4\src\extra\widgets\animimg;packages\LVGL-v8.3.4\src\extra\others;packages\LVGL-v8.3.4\src\extra\libs\bmp;packages\LVGL-v8.3.4\src\extra\widgets\calendar;packages\LVGL-v8.3.4\src\draw\arm2d;board\port;..\..\..\components\drivers\include;..\..\..\components\drivers\include;packages\LVGL-v8.3.4\env_support\rt-thread;packages\LVGL-v8.3.4\src\hal;..\..\..\components\drivers\include;packages\ft6236-latest\inc;..\..\..\components\drivers\include;packages\LVGL-v8.3.4\src\extra\themes\basic;applications;packages\LVGL-v8.3.4\src\extra\others\msg;..\..\..\libcpu\arm\cortex-m7;packages\LVGL-v8.3.4\src\draw\stm32_dma2d;packages\LVGL-v8.3.4\src\draw\nxp\pxp;packages\LVGL-v8.3.4\src\extra\layouts\grid;applications\lvgl;packages\LVGL-v8.3.4\src\extra\widgets\msgbox;..\..\..\components\libc\posix\io\poll;packages\LVGL-v8.3.4\src\misc;..\..\..\include;packages\LVGL-v8.3.4\src\extra\libs\gif;packages\LVGL-v8.3.4\src\extra\widgets\imgbtn;packages\LVGL-v8.3.4\src\extra\libs\png;packages\LVGL-v8.3.4\src\extra\widgets\win;packages\LVGL-v8.3.4\src\extra\widgets\tabview;packages\LVGL-v8.3.4\src;packages\LVGL-v8.3.4\src\draw\swm341_dma2d;packages\LVGL-v8.3.4\src\extra\libs\qrcode;packages\LVGL-v8.3.4\src\extra\themes\mono;packages\LVGL-v8.3.4\src\extra\libs\fsdrv;..\..\..\components\libc\compilers\common\extension;packages\LVGL-v8.3.4\src\extra\widgets\menu;packages\LVGL-v8.3.4\src\draw\sdl;packages\LVGL-v8.3.4\src\widgets;packages\LVGL-v8.3.4\src\extra\widgets\spinner;packages\LVGL-v8.3.4\src\extra;packages\LVGL-v8.3.4\src\extra\others\imgfont;packages\LVGL-v8.3.4\src\extra\widgets\keyboard;packages\LVGL-v8.3.4\src\extra\libs;packages\LVGL-v8.3.4\src\extra\libs\sjpg;packages\LVGL-v8.3.4\src\extra\widgets;packages\LVGL-v8.3.4\src\extra\others\ime;packages\LVGL-v8.3.4\src\extra\widgets\list;packages\LVGL-v8.3.4\src\extra\themes\default;packages\gui_guider_demo-latest\custom;packages\LVGL-v8.3.4\src\extra\widgets\colorwheel;packages\LVGL-v8.3.4\src\core;packages\LVGL-v8.3.4\src\extra\others\fragment;..\..\..\components\drivers\include;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;packages\gui_guider_demo-latest;.;packages\LVGL-v8.3.4\src\extra\widgets\chart;packages\LVGL-v8.3.4\src\extra\libs\ffmpeg;packages\LVGL-v8.3.4\src\extra\layouts;packages\LVGL-v8.3.4\src\extra\widgets\meter;packages\LVGL-v8.3.4\src\draw\sw;packages\gui_guider_demo-latest\generated;..\..\..\components\drivers\spi;packages\LVGL-v8.3.4\src\extra\widgets\tileview;packages\LVGL-v8.3.4\src\extra\others\gridnav;packages\gui_guider_demo-latest\generated\guider_fonts;packages\LVGL-v8.3.4\src\draw\nxp\vglite;packages\gui_guider_demo-latest\generated\images;packages\gui_guider_demo-latest\generated\guider_customer_fonts;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\drivers\touch;..\libraries\HAL_Drivers\config;packages\LVGL-v8.3.4\src\extra\themes;..\..\..\components\libc\compilers\common\include;..\libraries\HAL_Drivers\CMSIS\Include;packages\LVGL-v8.3.4\src\extra\libs\freetype;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;packages\LVGL-v8.3.4\src\extra\widgets\led;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.4\src\extra\widgets\spinbox;..\..\..\components\libc\posix\ipc;packages\LVGL-v8.3.4\src\extra\others\monkey;board;..\..\..\components\finsh;board\CubeMX_Config\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cm_backtrace.c cmb_port.c cmb_flash_log.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial_v2.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/touch/: touch.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    board/port/: drv_spi_ili9488.c
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_sdram.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group ft6236
    packages/ft6236-latest/src/: ft6236.c
  group GUI-Guider-demo
    packages/gui_guider_demo-latest/generated/: setup_scr_screen.c gui_guider.c events_init.c
    packages/gui_guider_demo-latest/generated/guider_fonts/: lv_font_simsun_12.c
    packages/gui_guider_demo-latest/custom/: custom.c
    packages/gui_guider_demo-latest/: lv_gui_guider_demo.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_i2c.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group LVGL
    packages/LVGL-v8.3.4/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.4/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.4/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.4/src/draw/: lv_img_buf.c lv_draw_transform.c lv_draw.c lv_draw_rect.c lv_draw_img.c lv_draw_layer.c lv_img_cache.c lv_img_decoder.c lv_draw_label.c lv_draw_arc.c lv_draw_mask.c lv_draw_line.c lv_draw_triangle.c
    packages/LVGL-v8.3.4/src/font/: lv_font_montserrat_22.c lv_font_montserrat_28.c lv_font_montserrat_18.c lv_font_montserrat_24.c lv_font_montserrat_36.c lv_font_montserrat_48.c lv_font_montserrat_46.c lv_font_montserrat_32.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_40.c lv_font_fmt_txt.c lv_font_montserrat_30.c lv_font_montserrat_26.c lv_font_unscii_8.c lv_font_montserrat_28_compressed.c lv_font.c lv_font_montserrat_42.c lv_font_montserrat_10.c lv_font_montserrat_14.c lv_font_montserrat_38.c lv_font_montserrat_12_subpx.c lv_font_montserrat_34.c lv_font_montserrat_12.c lv_font_montserrat_44.c lv_font_montserrat_16.c lv_font_unscii_16.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_20.c lv_font_simsun_16_cjk.c
    packages/LVGL-v8.3.4/src/widgets/: lv_arc.c lv_label.c lv_img.c lv_canvas.c lv_checkbox.c lv_bar.c lv_switch.c lv_roller.c lv_table.c lv_line.c lv_textarea.c lv_dropdown.c lv_btnmatrix.c lv_btn.c lv_objx_templ.c lv_slider.c
    packages/LVGL-v8.3.4/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.4/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.4/src/misc/: lv_area.c lv_templ.c lv_printf.c lv_style.c lv_timer.c lv_bidi.c lv_anim_timeline.c lv_log.c lv_color.c lv_tlsf.c lv_txt_ap.c lv_mem.c lv_async.c lv_style_gen.c lv_math.c lv_lru.c lv_utils.c lv_txt.c lv_anim.c lv_fs.c lv_gc.c lv_ll.c
    packages/LVGL-v8.3.4/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.4/src/draw/sdl/: lv_draw_sdl_polygon.c lv_draw_sdl_texture_cache.c lv_draw_sdl_rect.c lv_draw_sdl_arc.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_utils.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl.c lv_draw_sdl_layer.c lv_draw_sdl_stack_blur.c lv_draw_sdl_mask.c lv_draw_sdl_img.c
    packages/LVGL-v8.3.4/src/extra/libs/fsdrv/: lv_fs_win32.c lv_fs_stdio.c lv_fs_posix.c lv_fs_fatfs.c
    packages/LVGL-v8.3.4/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.4/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.4/src/draw/sw/: lv_draw_sw_dither.c lv_draw_sw.c lv_draw_sw_letter.c lv_draw_sw_img.c lv_draw_sw_polygon.c lv_draw_sw_blend.c lv_draw_sw_arc.c lv_draw_sw_layer.c lv_draw_sw_line.c lv_draw_sw_gradient.c lv_draw_sw_transform.c lv_draw_sw_rect.c
    packages/LVGL-v8.3.4/src/core/: lv_obj_class.c lv_obj_style.c lv_disp.c lv_obj_draw.c lv_obj_scroll.c lv_theme.c lv_indev.c lv_group.c lv_obj_style_gen.c lv_obj.c lv_obj_tree.c lv_event.c lv_indev_scroll.c lv_obj_pos.c lv_refr.c
    packages/LVGL-v8.3.4/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.4/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.4/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.4/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.4/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.4/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.4/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.4/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.4/src/extra/: lv_extra.c
    packages/LVGL-v8.3.4/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.4/src/draw/nxp/vglite/: lv_gpu_nxp_vglite.c lv_draw_vglite_rect.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c
    packages/LVGL-v8.3.4/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.4/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.4/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.4/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.4/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.4/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.4/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.4/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.4/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.3.4/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.4/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.4/src/draw/nxp/: lv_gpu_nxp.c
    packages/LVGL-v8.3.4/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v8.3.4/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.4/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.4/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.4/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    packages/LVGL-v8.3.4/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.4/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.4/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.4/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.4/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.4/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.4/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.4/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.4/src/extra/libs/freetype/: lv_freetype.c
  group LVGL-demo
    packages/lv_music_demo-v0.3.2/assets/: img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_wave_top.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_btn_pause.c
    packages/lv_music_demo-v0.3.2/: lv_demo_rtt_music_list.c lv_demo_rtt_music.c lv_demo_rtt_music_main.c
  group LVGL-port
    applications/lvgl/: lv_demo.c lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.4/env_support/rt-thread/: lv_rt_thread_port.c
